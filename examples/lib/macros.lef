VERSION 5.8 ;
MACRO SRAM_SP_32KX128
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 1450.2 BY 820.6 ;
  SYMMETRY X Y R90 ;
END SRAM_SP_32KX128
MACRO SRAM_SP_16KX512
  CLASS BLOCK ;
  SIZE 980.0 BY 1210.4 ;
END SRAM_SP_16KX512
MACRO PCIE_PHY_X4
  CLASS BLOCK ;
  SIZE 900.0 BY 1800.0 ;
END PCIE_PHY_X4
MACRO DDR_PHY_X32
  CLASS BLOCK ;
  SIZE 2400.0 BY 700.0 ;
END DDR_PHY_X32
MACRO ETH_SERDES
  CLASS BLOCK ;
  SIZE 600.0 BY 1100.0 ;
END ETH_SERDES
MACRO PLL_1G
  CLASS BLOCK ;
  SIZE 300.0 BY 260.0 ;
END PLL_1G
